# Keil uVision project DigitSensor.uvprojx, settings and files
target DigitSensor (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DIgitSensor
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=3
  c define: AMX_ANSIONLY
  c include: .\inc;.\ThirdParty\FreeRTOS\inc;.\ThirdParty\LittleFS\inc;.\ThirdParty\Pawn;.\ThirdParty\ymodem;.\ThirdParty\Ucglib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./src/: AD8402_driver.c DataBase.c DigitResistor.c main.c W25Q16JVSNIQ_driver.c Sensors.c iPawn.c hardware.c iFS.c ST7735_driver.c UI.c Fonts.c ValveDetect.c MainLogic.c StoreFiles.c EncoderControl.c
  group inc
    ./inc/: AD8402_driver.h ST7735_driver.h DataBase.h hardware.h iPawn.h W25Q16JVSNIQ_driver.h UI.h Sensors.h DigitResistor.h ValveDetect.h MainLogic.h StoreFiles.h EncoderControl.h
  group FreeRTOS-src
    ./ThirdParty/FreeRTOS/src/: event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS-inc
    ./ThirdParty/FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_syscall_numbers.h mpu_wrappers.h portable.h portmacro.h projdefs.h mpu_prototypes.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group LittleFS-src
    ./ThirdParty/LittleFS/src/: lfs.c lfs_util.c
  group LittleFS-inc
    ./ThirdParty/LittleFS/inc/: lfs_util.h lfs.h
  group Pawn
    ./ThirdParty/Pawn/: amx.c amx.h amxcore.c
  group Ymodem
    ./ThirdParty/ymodem/: ymodem.c ymodem.h
  group Ucglib
    ./ThirdParty/Ucglib/: ucg.h ucg_box.c ucg_circle.c ucg_clip.c ucg_com_msg_api.c ucg_dev_default_cb.c ucg_dev_ic_st7735.c ucg_dev_msg_api.c ucg_dev_tft_128x160_st7735.c ucg_font.c ucg_init.c ucg_line.c ucg_pixel.c ucg_polygon.c ucg_scale.c ucg_bitmap.c ucg_ccs.c ucg_rotate.c
software components: CMSIS:CORE 6.2.0, Device:Startup 2.6.3
